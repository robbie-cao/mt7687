# IAR project battery_management_get_status.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_DEBUG_LEVEL_INFO; PRODUCT_VERSION=2523; MTK_SMART_BATTERY_ENABLE
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt2523\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\middleware\MTK\battery_management\inc; ..\..\..\..\..\middleware\MTK\battery_management\lib\fuelgauge\inc; ..\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\ept\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\keypad\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: battery_management_get_status.bin
  ILINK.IlinkOutputFile: battery_management_get_status.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../src/: battery_message.c ept_eint_var.c ept_gpio_var.c main.c sys_init.c
  group board
    ../../../../../driver/board/mt25x3_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/mt25x3_hdk/keypad/src/: keypad_custom.c
  group cmsis
    ./: startup_mt2523.s
    ../src/: system_mt2523.c
  group driver
    ../../../../../driver/chip/mt2523/src/: hal_accdet.c hal_accdet_internal.c hal_adc.c hal_audio.c hal_audio_custom.c hal_audio_enhancement.c hal_audio_fw_interface.c hal_audio_fw_slt.c hal_audio_internal_afe.c hal_audio_internal_pcm.c hal_audio_internal_pcm2way.c hal_audio_internal_service.c hal_audio_internal_vm.c hal_audio_low_power.c hal_audio_post_processing.c hal_audio_test.c hal_bsi.c hal_cache.c hal_cache_internal.c hal_charger.c hal_clock_internal.c hal_dac.c hal_dcm.c hal_dcxo.c hal_display_color.c hal_display_color_internal.c hal_display_dsi.c hal_display_dsi_internal.c hal_display_lcd.c hal_display_lcd_internal.c hal_display_pwm.c hal_display_pwm_internal.c hal_dvfs.c hal_dvfs_internal.c hal_dvfs_internal_vcore.c hal_eint.c hal_eint_internal.c hal_emi.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_g2d_common_api.c hal_g2d_drv_common.c hal_g2d_drv_overlay.c hal_g2d_drv_rectfill.c hal_g2d_overlay_api.c hal_g2d_rectfill_api.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2c_pmic.c hal_i2s.c hal_i2s_internal.c hal_i2s_internal_pcm_route.c hal_isink.c hal_keypad.c hal_keypad_internal.c hal_keypad_powerkey_internal.c hal_log.c hal_misc.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_auxadc.c hal_pmu_internal.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_trng.c hal_trng_internal.c hal_uart.c hal_uart_internal.c hal_uart_internal_platform.c hal_usb.c hal_usb_phy.c hal_wdt.c hal_wdt_internal.c hal_wdt_retention.c hal_weak.c
  group kernel
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group kservice
    ../../../../../kernel/service/lib/: libkservice_CM4_MT2523_IAR.a
    ../../../../../kernel/service/src/: memory_regions.c os_port_callback.c
  group lib
    ../../../../../middleware/MTK/battery_management/lib/: libfgauge_IAR.a
    ../../../../../driver/chip/mt2523/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
  group middleware
    ../../../../../middleware/MTK/battery_management/src/: battery_management_core.c battery_management_driver.c battery_management_meter.c
