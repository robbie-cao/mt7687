# Keil uVision project iot_sdk_demo.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MT2523x MediaTek
  pack: MediaTek.MTx.3.3.0
  cpu: IROM(0x08000000,0x00400000) IRAM(0x00000000,0x00400000) IRAM2(0x04008000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: iot_sdk_demo +hex
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: MTK_DEBUG_LEVEL_INFO,PRODUCT_VERSION=2523 MTK_SENSOR_ACCELEROMETER_USE MTK_SENSOR_ACCELEROMETER_USE_BMA255 MTK_SENSOR_BIO_USE MTK_SENSOR_BIO_USE_MT2511 FUSION_HEART_RATE_MONITOR_USE=M_INHOUSE_HEART_RATE_MONITOR FUSION_HEART_RATE_VARIABILITY_USE=M_INHOUSE_HEART_RATE_VARIABILITY SENSOR_FUSTION_TASK_ENABLED SENSOR_DEMO MTK_CTP_ENABLE  configOVERRIDE_DEFAULT_TICK_CONFIGURATION MTK_BT_AT_COMMAND_ENABLE MTK_DEVELOPMENT_BOARD_HDK MTK_SMART_BATTERY_ENABLE
  c misc: --c99 --diag_suppress=161
  c include: ..\inc;..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt2523\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\chip\mt2523\src\common\include;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\board\component\common;..\..\..\..\..\driver\board\component\lcm\ST7789H2;..\inc\bt_audio;..\inc\bt_audio\sink;..\..\..\..\..\middleware\MTK\bluetooth\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\inc\graphicLib;..\..\..\..\..\middleware\MTK\atci\inc;..\inc\gnss_screen;..\inc\pxp_screen;..\inc\sensor_demo;..\inc\watch_face;..\..\..\..\..\driver\board\mt25x3_hdk\lcd;..\..\..\..\..\middleware\MTK\sensor_subsys\inc;..\..\..\..\..\driver\board\component\mems\inc;..\..\..\..\..\driver\board\component\mems\inc\libyas533;..\..\..\..\..\middleware\MTK\gnss\inc;..\..\..\..\..\driver\board\mt25x3_hdk\backlight;..\..\..\..\..\middleware\MTK\audio\inc;..\..\..\..\..\driver\board\component\biosensor\mt2511\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\MTK\nvdm\src\nvdm_internal.h;..\..\..\..\..\middleware\MTK\nvdm\src\portable;..\..\..\..\..\driver\board\mt25x3_hdk\bt_codec\inc;..\..\..\..\..\driver\board\mt25x3_hdk\lcd;..\..\..\..\..\middleware\MTK\gnss\inc;..\..\..\..\..\driver\board\component\biosensor\mt2511\inc;..\..\..\..\..\driver\board\component\touch_panel\common\inc;..\..\..\..\..\middleware\MTK\audio\inc;..\..\..\..\..\driver\board\component\touch_panel\ctp_goodix_gt9xxx\gt9137;..\..\..\..\..\driver\board\component\bt_codec\inc;..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\gt9137;..\..\..\..\..\driver\board\component\biosensor\mt2511\module\default;..\..\..\..\..\driver\board\mt25x3_hdk\backlight;..\..\..\..\..\driver\board\component\mems\inc;..\..\..\..\..\driver\board\component\lcm\ST7789H2;..\..\..\..\..\driver\board\component\touch_panel\ctp_goodix_gt9xxx\gt9137;..\..\..\..\..\middleware\MTK\battery_management\inc;..\..\..\..\..\middleware\MTK\battery_management\lib\fuelgauge\inc;..\..\..\..\..\driver\board\mt76x7_hdk\init\inc;..\..\..\..\..\driver\board\component\biosensor\mt2511\inc;..\..\..\..\..\driver\board\component\biosensor\mt2511\module\default;..\..\..\..\..\driver\board\component\biosensor\mt2511\module\everlight;..\..\..\..\..\middleware\MTK\sensor_subsys\fusion_algo\agc\inc\;..\..\..\..\..\middleware\MTK\sensor_subsys\fusion_algo\common\inc\;..\..\..\..\..\middleware\MTK\sensor_subsys\fusion_algo\heart_rate\inc\;..\..\..\..\..\middleware\MTK\sensor_subsys\fusion_algo\heart_rate_variability\inc\;..\..\..\..\..\middleware\MTK\sensor_subsys\fusion_algo\ppg_control\inc\;..\..\..\..\..\driver\board\mt25x3_hdk\keypad\inc;..\..\..\..\..\driver\board\component\touch_panel\ctp_ite_it7xxx\it7258;..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\it7258;..\..\..\..\..\driver\board\mt25x3_hdk\ept\inc;..\..\..\..\..\middleware\third_party\kiss_fft
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x0 size 0x400000
  memory RVCT10: RAM 0x4008000 size 0x20000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __Vectors --debug
  group app
    ../src/: main.c ept_eint_var.c ept_gpio_var.c hci_log.c task_def.c
  group cmsis
    ../src/: system_mt2523.c
    ./: startup_mt2523.s
  group kernel
    ../../../../../kernel/rtos/FreeRTOS/Source/: timers.c list.c queue.c tasks.c event_groups.c croutine.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/mt2523/: port_tickless.c
  group lib
    ../../../../../driver/chip/mt2523/lib/: libhal_protected_CM4_Keil.lib libhal_core_CM4_Keil.lib
    ../../../../../middleware/MTK/bluetooth/lib/: libbt_2523_CM4_keil.lib
    ../../../../../middleware/MTK/battery_management/lib/: libfgauge.lib
  group bt_audio
    ../src/bt_audio/sink/: bt_sink_a2dp.c bt_sink_am_task.c bt_sink_ami.c bt_sink_avrcp.c bt_sink_common_cb.c bt_sink_conmgr.c bt_sink_custom_db.c bt_sink_db.c bt_sink_event.c bt_sink_hf.c bt_sink_hf_call_manager.c bt_sink_hf_multipoint.c bt_sink_music.c bt_sink_queue.c bt_sink_task.c bt_sink_utils.c
    ../src/bt_audio/: bt_audio.c bt_common_dispatch.c
    ../../../../../middleware/MTK/audio/src/: audio_middleware_api.c audio_nvdm.c
  group gnss_screen
    ../src/gnss_screen/: epo_demo.c gnss_app.c gnss_demo_screen.c gnss_ring_buffer.c gnss_timer.c
  group graphic
    ../src/graphicLib/: FontRes.c gd_primitive16.c gdi_font.c gdi_layer.c gdi_lcd.c gdi_primitive.c main_screen.c PixcomFontEngine.c ui_demo_task.c
  group pxp_screen
    ../src/pxp_screen/: ble_gatts_srv_common.c ble_ias.c ble_lls.c ble_message.c ble_pxp_main.c ble_static_callback.c ble_tps.c
  group sensor
    ../src/sensor_demo/: sensor_demo.c sensor_demo_screen.c
  group watch_face
    ../src/watch_face/: watch_face_app.c wf_image.c
  group sensor_subsys
    ../../../../../middleware/MTK/sensor_subsys/src/: sensor_manager.c sensor_manager_driver.c
  group mems
    ../../../../../driver/board/component/mems/src/: mems_bus.c bma2x2.c bma255_i2c_operation.c bma255_sensor_adaptor.c
    ../../../../../driver/board/component/biosensor/mt2511/src/: vsm_driver.c vsm_i2c_operation.c vsm_sensor_subsys_adaptor.c
  group atci
    ../../../../../middleware/MTK/atci/src/: atci_adapter.c atci_handler.c atci_main.c
  group at_cmd
    ../../../../../middleware/MTK/atci/at_command/: at_command.c at_command_audio.c at_command_audio_tuning.c at_command_audio_tuning_db_to_gain_value_mapping_table.c at_command_backlight.c at_command_biogui.c at_command_bt.c at_command_camera.c at_command_charger.c at_command_clover.c at_command_crypto.c at_command_ctp.c at_command_dvfs.c at_command_gnss.c at_command_gsensor.c at_command_keypad.c at_command_lcm.c at_command_led.c at_command_msdc.c at_command_nvdm.c at_command_pmu.c at_command_reg.c at_command_rtc.c at_command_sensor.c at_command_sleep_manager.c at_command_syslog.c at_command_vibrator.c at_command_wdt.c at_command_gpio.c
    ../../../../../middleware/third_party/kiss_fft/: kiss_fft.c
  group nvdm
    ../../../../../middleware/MTK/nvdm/src/: nvdm_port.c
    ../../../../../middleware/MTK/nvdm/lib/: libnvdm_CM4_KEIL.lib
  group board
    ../../../../../driver/board/mt25x3_hdk/lcd/: mt25x3_hdk_lcd.c
    ../../../../../driver/board/mt25x3_hdk/gnss/: gnss_config.c
    ../../../../../driver/board/component/touch_panel/common/src/: bsp_ctp.c ctp.c ctp_i2c.c
    ../../../../../driver/board/mt25x3_hdk/bt_codec/src/: bt_a2dp_codec.c bt_hfp_codec.c
    ../../../../../driver/board/mt25x3_hdk/backlight/: mt25x3_hdk_backlight.c
    ../../../../../driver/board/component/lcm/ST7789H2/: lcd.c
    ../../../../../driver/board/component/touch_panel/ctp_goodix_gt9xxx/gt9137/: ctp_goodix_gt9xxx.c
    ../../../../../driver/board/component/bt_codec/lib/arm_cm4/: libcvsd_codec_CM4_Keil.lib libmsbc_codec_CM4_Keil.lib libplc_CM4_Keil.lib
    ../../../../../driver/board/mt25x3_hdk/keypad/src/: keypad_custom.c
    ../../../../../driver/board/mt25x3_hdk/touch_panel/it7258/: touch_panel_custom_ite.c
    ../../../../../driver/board/mt25x3_hdk/touch_panel/gt9137/: touch_panel_custom_goodix.c
    ../../../../../driver/board/component/touch_panel/ctp_ite_it7xxx/it7258/: ctp_ite_it7xxx.c ctp_ite_it7xxx_download.c
    ../../../../../driver/board/mt25x3_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/component/lcm/RM69032/: lcd_RM69032.c
  group gnss
    ../../../../../middleware/MTK/gnss/src/: gnss_api.c gnss_driver.c
  group hal
    ../../../../../driver/chip/mt2523/src/: hal_accdet.c hal_accdet_internal.c hal_adc.c hal_audio.c hal_audio_custom.c hal_audio_enhancement.c hal_audio_internal_afe.c hal_audio_internal_pcm.c hal_audio_internal_pcm2way.c hal_audio_internal_service.c hal_audio_internal_vm.c hal_audio_low_power.c hal_audio_post_processing.c hal_audio_test.c hal_bsi.c hal_cache.c hal_cache_internal.c hal_charger.c hal_dac.c hal_dcm.c hal_dcxo.c hal_display_color.c hal_display_color_internal.c hal_display_dsi.c hal_display_dsi_internal.c hal_display_lcd.c hal_display_lcd_internal.c hal_display_pwm.c hal_display_pwm_internal.c hal_dvfs.c hal_dvfs_internal.c hal_dvfs_internal_vcore.c hal_eint.c hal_eint_internal.c hal_emi.c hal_audio_fw_interface.c hal_audio_fw_slt.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2c_pmic.c hal_i2s.c hal_i2s_internal.c hal_i2s_internal_pcm_route.c hal_isink.c hal_keypad.c hal_keypad_internal.c hal_keypad_powerkey_internal.c hal_log.c hal_misc.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_auxadc.c hal_pmu_internal.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_trng.c hal_trng_internal.c hal_uart.c hal_uart_internal.c hal_uart_internal_platform.c hal_usb.c hal_usb_phy.c hal_wdt.c hal_wdt_internal.c hal_wdt_retention.c hal_weak.c hal_clock_internal.c hal_g2d_common_api.c hal_g2d_drv_common.c hal_g2d_drv_overlay.c hal_g2d_drv_rectfill.c hal_g2d_overlay_api.c hal_g2d_rectfill_api.c
  group syslog
    ../../../../../kernel/service/lib/: libkservice_CM4_MT2523_Keil.lib
    ../../../../../kernel/service/src/: memory_regions.c os_port_callback.c
  group battery_management
    ../../../../../middleware/MTK/battery_management/src/: battery_management_core.c battery_management_driver.c battery_management_meter.c
  group sensor_fusion
    ../../../../../middleware/MTK/sensor_subsys/src/algo_adaptor/: algo_adaptor.c heart_rate_monitor_adaptor.c heart_rate_variability_monitor_adaptor.c
    ../../../../../middleware/MTK/sensor_subsys/fusion_algo/common/lib_core/: libcomm_CM4_KEIL.lib
    ../../../../../middleware/MTK/sensor_subsys/fusion_algo/heart_rate/lib_core/: libhr_CM4_KEIL.lib
    ../../../../../middleware/MTK/sensor_subsys/fusion_algo/heart_rate_variability/lib_core/: libhrv_CM4_KEIL.lib
    ../../../../../middleware/MTK/sensor_subsys/fusion_algo/ppg_control/lib_core/: libppgctrl_CM4_KEIL.lib
