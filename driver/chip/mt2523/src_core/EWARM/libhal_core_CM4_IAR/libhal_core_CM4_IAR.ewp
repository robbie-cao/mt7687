# IAR project libhal_core_CM4_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_DEBUG_LEVEL_INFO; PRODUCT_VERSION=2523
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: inc; ..\..\..\..\inc; ..\..\..\inc; ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\CMSIS\Device\MTK\mt2523\Include; ..\..\..\..\..\..\kernel\service\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: libhal_core_CM4_IAR.bin
  ILINK.IlinkOutputFile: i2c_communication_with_EEPROM_polling.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: hal_clock.c hal_cm4_topsm.c hal_cm4_topsm_internal.c hal_dsp_topsm.c hal_ostd.c hal_sleep_driver.c hal_sleep_manager.c hal_sys_topsm.c
