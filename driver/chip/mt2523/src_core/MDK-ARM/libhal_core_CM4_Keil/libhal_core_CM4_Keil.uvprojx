# Keil uVision project libhal_core_CM4_Keil.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MT2523x MediaTek
  pack: MediaTek.MTx.3.1.0
  cpu: IROM(0x08000000,0x00400000) IRAM(0x00000000,0x00400000) IRAM2(0x04008000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: libhal_core_CM4_Keil (library)
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\..\inc;..\..\..\..\inc;.\inc;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\CMSIS\Device\MTK\mt2523\Include;..\..\..\..\..\..\kernel\service\inc
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x0 size 0x400000
  memory RVCT10: RAM 0x4008000 size 0x20000
  group hal_core
    ../../: hal_clock.c hal_cm4_topsm.c hal_cm4_topsm_internal.c hal_dsp_topsm.c hal_ostd.c hal_sleep_driver.c hal_sleep_manager.c hal_sys_topsm.c
